

VOLATILE_BINDS = "\
    /var/volatile/cache /var/cache\n\
    /var/volatile/log /var/log\n\
    /app/var-lib /var/lib\n\
    /app/var-spool /var/spool\n\
"