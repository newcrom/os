# See https://github.com/raspberrypi/linux/commit/9b0efcc1ec497b2985c6aaa60cd97f0d2d96d203
CMDLINE:append=" cgroup_enable=cpuset cgroup_memory=1 cgroup_enable=memory"